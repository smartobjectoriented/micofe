# Copyright (c) 2025-2026 EDGEMTech SA
# Adapted for MICOFE - Copyright (c) 2026 REDS Institute, HEIG-VD

# Class for building U-boot in infrabase

IB_UBOOT_PATH = "${IB_DIR}/u-boot"


