# Copyright (c) 2025-2026 EDGEMTech SA
# Adapted for MICOFE - Copyright (c) 2026 REDS Institute, HEIG-VD

# Specific task description for formatting
# the storage of Raspberry Pi 4 (32-bit) (rpi4) platform

inherit fs_arm_common
