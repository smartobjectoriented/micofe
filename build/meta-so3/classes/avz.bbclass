# Copyright (c) 2025-2026 EDGEMTech SA
# Adapted for MICOFE - Copyright (c) 2026 REDS Institute, HEIG-VD

# Class for building SO3 in infrabase

IB_AVZ_PATH = "${IB_DIR}/avz"

